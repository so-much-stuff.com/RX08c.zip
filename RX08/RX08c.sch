# EAGLE board RX08c (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$93  (via drill 0.61)
  Top 0.254: v110.49,104.78 110.49,96.52 109.22,95.25 E26.8 | v142.24,104.78 142.24,102.87 E20.5
  Bottom 0.254: v110.49,104.78 111.12,104.14 141.6,104.14 v142.24,104.78
N$94
  Top 0.254: R18.1 66.04,80.64 66.04,80.01 63.5,77.47 IC9.3 63.5,74.93 67.31,71.12 67.31,58.42 74.93,58.42 81.92,65.41 89.53,65.41 90.81,64.14 E30.11
N$95
  Bottom 0.254: IC9.2 66.67,76.83 67.94,78.11 83.19,78.11 E31.8
N$96  (via drill 0.61)
  Top 0.254: v133.99,87 133.99,67.94 137.16,64.77 E18.8 | v139.7,89.53 142.24,92.08 142.24,92.71 E20.10
  Bottom 0.254: v133.99,87 136.53,89.53 v139.7,89.53
N$97
  Bottom 0.254: E6.8 219.07,79.38 223.52,83.82 228.6,83.82 230.5,85.72 E6.2
N$98  (via drill 0.61)
  Top 0.254: v74.93,83.82 68.58,77.47 IC9.1
  Bottom 0.254: v74.93,83.82 75.56,84.45 84.45,84.45 85.72,85.72 E31.6
N$99
  Bottom 0.254: E30.13 97.16,64.14 98.42,65.41 107.31,65.41 108.58,64.14 E24.8
N$100  (via drill 0.61)
  Top 0.254: v114.3,83.82 114.3,80.01 E25.10 | v212.09,83.82 213.36,82.55 213.36,60.96 219.71,54.61 219.71,34.29 224.79,29.21 224.79,24.13 226.06,22.86 226.06,21.59 E2.12
  Bottom 0.254: v212.09,83.82 v114.3,83.82
N$101  (via drill 0.61)
  Top 0.254: v120.65,97.16 120.65,81.28 119.38,80.01 E25.12
  Bottom 0.254: v120.65,97.16 121.28,96.52 137.79,96.52 138.43,95.89 153.67,95.89 154.31,96.52 172.72,96.52 173.99,95.25 173.99,92.08 213.36,92.08 216.53,88.9 234.31,88.9 237.49,85.72 237.49,18.41 225.43,18.41 224.16,19.68 E2.11
N$102
  Bottom 0.254: E31.13 97.16,79.38 98.42,80.64 99.69,80.64 100.33,80.01 100.33,78.74 108.58,78.74 E25.8
N$104
  Bottom 0.254: E10.6 196.22,102.23 197.49,103.5 206.38,103.5 207.65,102.23 E10.1
N$105
  Bottom 0.254: E10.10 198.75,93.34 200.03,93.34 E10.11 201.29,93.34 202.56,93.34 E10.12
N$106  (via drill 0.61)
  Top 0.254: IC7.2 66.67,100.97 67.94,100.97 IC7.1 68.58,100.33 v72.39,96.52 | v135.25,110.49 125.73,100.97 v125.73,97.79
  Bottom 0.254: v135.25,110.49 209.55,110.49 209.55,100.33 207.01,97.79 196.85,97.79 193.68,94.61 E10.8 | v125.73,97.79 125.09,98.42 119.38,98.42 117.47,96.52 v72.39,96.52
PARITY
  Top 0.254: E15.13 177.8,66.04 177.8,71.12 E15.2
  Bottom 0.254: E4.15 231.14,46.99 231.14,51.44 234.31,51.44 234.95,52.07 234.95,60.96 192.41,60.96 190.5,62.87 179.71,62.87 178.44,64.14 E15.13 | E15.1 179.71,71.75 178.44,71.75 E15.2
PARITY\  (via drill 0.61)
  Top 0.254: v177.8,89.53 176.53,88.27 176.53,82.55 173.99,80.01 173.99,69.85 175.26,68.58 175.26,66.04 E15.12
  Bottom 0.254: v177.8,89.53 172.09,89.53 168.28,93.34 E17.10
RD  (via drill 0.61)
  Top 0.254: E35.10 37.47,32.38 36.2,31.11 34.29,31.11 34.29,70.48 46.99,83.19 46.99,95.25 49.53,97.79 49.53,98.42 57.15,106.05 95.25,106.05 95.25,100.33 94.61,99.69 92.71,99.69 92.71,102.87 92.08,103.5 90.17,103.5 90.17,100.33 88.9,99.06 88.9,95.25 E32.10 88.9,92.71 v88.9,90.81
  Bottom 0.254: v88.9,90.81 90.81,88.9 115.57,88.9 116.2,88.27 122.56,88.27 123.83,87 E25.1
RUN  (via drill 0.61)
  Top 0.254: v63.5,52.07 63.5,67.31 IC9.6 64.14,67.94 65.41,67.94 IC9.7
  Bottom 0.254: v63.5,52.07 57.78,52.07 52.07,46.35 42.55,46.35 41.27,47.62 E36.11 | E30.9 85.72,64.14 83.19,66.67 67.94,66.67 66.67,67.94 IC9.7
RX_12_BIT\
  Top 0.254: R7.1 23.5,22.86 24.77,22.86 R16.2 | IC8.3 17.78,66.04 16.51,64.77 16.51,27.3 12.7,23.5 DRIVE.FF
  Bottom 0.254: R7.1 22.23,22.86 20.95,21.59 14.61,21.59 13.34,22.86 DRIVE.FF
RX_DATA  (via drill 0.61)
  Top 0.254: v120.65,13.97 120.65,38.1 121.92,39.37 E22.3
  Bottom 0.254: v120.65,13.97 57.15,13.97 57.15,31.11 52.07,36.2 51.44,36.2 48.26,39.37 E35.1 | E22.2 123.83,40.01 122.56,40.01 E22.3
RX_DATA\  (via drill 0.61)
  Top 0.254: R8.1 18.41,22.86 19.68,22.86 R17.2 | v52.07,87 50.16,85.09 50.16,54.61 46.99,51.44 46.99,43.18 45.72,41.91 E35.2
  Bottom 0.254: 19.05,27.94 13.34,27.94 DRIVE.BB | 19.05,27.94 24.77,27.94 31.75,34.92 40.01,34.92 45.09,40.01 E35.2 | v52.07,87 53.98,87 60.33,93.34 IC7.5 | 19.05,27.94 19.05,24.77 17.78,23.5 R8.1
RX_DONE\
  Top 0.254: R4.1 23.5,48.26 24.77,48.26 R13.2
  Bottom 0.254: E36.8 32.38,48.26 26.04,48.26 R13.2 | DRIVE.X 12.06,33.02 10.79,34.29 9.53,34.29 8.26,35.56 8.26,46.99 20.95,46.99 22.23,48.26 R4.1
RX_ERROR\  (via drill 0.61)
  Top 0.254: R14.2 18.41,48.26 19.68,48.26 R5.1 | v43.18,50.8 43.18,54.61 E36.3
  Bottom 0.254: v43.18,50.8 42.55,50.16 22.86,50.16 20.95,48.26 R5.1 | DRIVE.J 13.34,48.26 17.14,48.26 R14.2
RX_INIT\
  Top 0.254: R9.1 23.5,35.56 24.77,35.56 R20.1 | IC8.5 15.24,58.42 13.97,57.15 13.97,45.09 12.7,43.81 DRIVE.N
  Bottom 0.254: R9.1 22.23,35.56 20.95,34.29 15.88,34.29 13.34,36.83 12.06,36.83 11.43,37.47 11.43,43.18 12.06,43.18 DRIVE.N
RX_OUT\
  Top 0.254: 29.21,22.86 29.84,22.86 R3.1 | 29.21,22.86 28.57,22.86 R12.2 | 29.21,22.86 29.21,27.94 33.02,31.75 E35.8
  Bottom 0.254: DRIVE.RR 13.34,12.7 22.23,21.59 26.04,21.59 27.3,22.86 R12.2
RX_RUN\
  Top 0.254: IC9.5 60.96,67.31 60.96,61.59 R6.1
  Bottom 0.254: R6.1 61.59,60.96 64.14,63.5 65.41,63.5 R15.2 | DRIVE.D 13.34,53.34 17.78,57.78 36.2,57.78 46.35,67.94 60.33,67.94 IC9.5
RX_SHIFT\
  Top 0.254: R2.1 29.84,35.56 28.57,35.56 R10.2 27.94,34.92 27.94,33.66 21.59,27.3 21.59,17.78 13.34,17.78 DRIVE.LL
  Bottom 0.254: E35.5 38.1,39.37 38.1,36.2 30.48,36.2 R2.1
RX_TR_REQ\  (via drill 0.61)
  Top 0.254: R11.2 18.41,35.56 19.68,35.56 R1.1 | v36.83,38.73 36.83,53.34 38.1,54.61 E36.5
  Bottom 0.254: v36.83,38.73 34.92,36.83 22.23,36.83 20.95,35.56 R1.1 | DRIVE.T 13.34,38.1 15.88,35.56 17.14,35.56 R11.2
SDN4\  (via drill 0.61)
  Top 0.254: v156.84,42.55 157.48,43.18 157.48,67.31 156.84,67.94 156.84,71.75 157.48,72.39 157.48,88.27 155.57,90.17 155.57,92.71 153.67,94.61 153.67,97.79 151.13,100.33 151.13,102.87 144.78,109.22 140.97,109.22 140.97,96.52 139.7,95.25 E20.9
  Bottom 0.254: v156.84,42.55 167.64,31.75 E13.10
SER4\  (via drill 0.61)
  Top 0.254: v163.19,104.78 163.19,57.78 166.37,54.61 166.37,35.56 170.18,31.75 E13.11 | v144.78,104.78 144.78,102.87 E20.4
  Bottom 0.254: v163.19,104.78 v144.78,104.78
SHIFT
  Top 0.254: E35.4 40.64,39.37 39.37,38.1 39.37,31.75 40.01,31.11 44.45,31.11 44.45,34.29 45.09,34.92 49.53,34.92 49.53,33.66 50.16,33.02 53.34,33.02 53.34,91.44 62.23,100.33 62.23,102.87 64.77,105.41 93.98,105.41 93.98,102.87 E32.3
STR2\  (via drill 0.61)
  Top 0.254: v160.02,101.6 161.29,100.33 161.29,39.37 168.91,31.75 v168.91,21.59
  Bottom 0.254: v160.02,101.6 153.03,101.6 E20.1 | v168.91,21.59 172.09,18.41 E12.12
TR_SKIP\
  Top 0.254: E19.1 152.4,87.63 151.13,88.9 151.13,95.25 149.86,96.52 147.32,96.52 147.32,100.33 E20.3
  Bottom 0.254: E6.1 233.04,87 231.78,88.27 182.25,88.27 181.61,87.63 180.97,88.27 154.31,88.27 153.03,87 E19.1
VCC
  Top 0.508: E1.4 222.88,14.61 221.62,14.61 E1.5 220.98,16.51 220.98,19.05 E2.10 | C1.1 233.68,9.53 232.41,10.79 232.41,17.78 231.14,19.05 E2.14 | 232.41,36.2 233.68,34.92 C3.1 | 232.41,36.2 232.41,43.18 233.68,44.45 E4.16 | 234.95,60.33 233.68,61.59 233.68,62.23 E5.14 | 234.95,60.33 236.22,59.05 R19.1 | 234.95,76.2 233.68,77.47 E6.14 | 234.95,60.33 234.95,76.2 | 234.95,60.33 234.95,48.9 236.22,47.62 C4.1 | 232.41,36.2 232.41,23.5 233.68,22.23 C2.1 | 234.95,76.2 234.95,85.72 235.59,86.36 235.59,93.98 236.22,94.61 C7.1 | E11.16 182.88,6.35 181.61,7.62 181.61,15.24 182.88,16.51 E12.16 | E13.16 182.88,29.21 186.69,25.4 186.69,20.95 185.42,19.68 C12.1 | C8.1 210.82,65.41 212.09,66.67 212.09,78.11 210.82,79.38 C9.1 | E16.10 170.18,80.01 172.72,82.55 172.72,85.09 E16.4 172.72,87.63 171.45,88.9 171.45,99.06 172.72,100.33 E17.5 | E15.14 180.34,66.04 179.07,67.31 179.07,76.2 180.34,77.47 E16.14 | C14.1 185.42,52.7 184.15,53.98 184.15,64.14 182.88,65.41 C15.1 | C13.1 185.42,32.38 186.69,33.66 186.69,45.72 182.88,49.53 E14.16 | 128.27,30.48 128.27,20.95 129.54,19.68 C21.1 | 128.27,30.48 127,31.75 E22.16 | 128.27,30.48 128.27,45.72 127,46.99 E23.16 | E20.14 152.4,92.71 154.94,90.17 154.94,85.72 C19.1 154.94,84.45 154.94,82.55 152.4,80.01 E19.14 152.4,77.47 151.13,76.2 151.13,68.58 | 151.13,68.58 152.4,67.31 152.4,64.77 E18.14 | 151.13,68.58 149.86,69.85 E18.2 | C23.1 129.54,50.16 128.27,51.44 128.27,62.87 127,64.14 C24.1 | C39.1 27.94,61.59 32.38,66.04 32.38,71.12 C40.+ | C36.1 50.16,48.26 48.9,48.26 E36.14 48.26,46.99 49.53,45.72 49.53,36.2 50.8,34.92 C35.1 | 21.59,38.1 22.23,38.1 R4.2
  Top 0.508: 21.59,38.1 20.95,38.1 R5.2 20.32,37.47 21.59,36.2 21.59,28.57 20.32,27.3 20.32,26.04 R1.2 | R20.2 24.77,25.4 23.5,25.4 R9.2 | R3.2 30.48,13.34 31.75,14.61 31.75,23.5 30.48,24.77 R2.2 | 21.59,38.1 21.59,57.15 22.86,58.42 IC8.8 | R6.2 71.12,61.59 68.58,64.14 68.58,67.31 IC9.8 | C33.1 73.66,70.48 76.2,73.03 76.2,80.64 R18.2 76.2,81.92 76.2,92.08 73.66,94.61 C34.1 | E26.2 121.92,100.33 124.46,97.79 124.46,95.25 E26.14 124.46,92.71 125.73,91.44 125.73,81.92 127,80.64 C25.1 | IC3.8 86.36,19.05 85.09,20.32 85.09,30.48 86.36,31.75 IC2.8 86.36,34.29 87.63,35.56 87.63,50.8 | 87.63,50.8 88.9,52.07 88.9,60.96 | 87.63,50.8 86.36,49.53 IC6.8 | 88.9,60.96 88.9,62.23 E30.10 | C31.1 100.97,80.01 100.97,79.38 99.69,79.38 E31.14 98.42,78.11 92.08,71.75 E30.4 91.44,69.85 91.44,67.31 93.98,64.77 E30.12 93.34,62.87 93.34,60.96 88.9,60.96 | C29.1 101.6,50.16 102.87,51.44 102.87,61.59 101.6,62.87 C30.1
  Bottom 0.508: E10.14 208.91,94.61 209.55,95.25 210.19,95.25 C10.1 210.82,95.89 234.95,95.89 235.59,95.25 C7.1 | E1.14 231.78,8.26 232.41,8.89 233.04,8.89 C1.1 | E2.13 229.24,19.68 230.5,19.68 E2.14 231.78,20.95 232.41,20.95 233.04,21.59 C2.1 233.68,22.23 222.88,22.23 221.62,20.95 E2.10 | C4.1 235.59,46.99 234.95,46.35 234.31,46.35 E4.16 | E6.14 234.31,79.38 234.95,80.01 235.59,80.01 C6.1 | C5.1 235.59,64.77 234.95,64.77 234.31,64.14 E5.14 233.04,64.14 231.78,65.41 210.82,65.41 C8.1 210.19,64.77 209.55,64.77 208.91,64.14 E8.14 | E13.16 183.51,31.11 184.15,31.75 184.78,31.75 C13.1 | E11.16 183.51,5.71 184.15,6.35 184.78,6.35 C11.1 | E12.16 183.51,18.41 184.15,19.05 184.78,19.05 C12.1 | C9.1 210.19,80.01 207.01,80.01 206.38,79.38 IC10.8 205.1,79.38 203.84,80.64 182.88,80.64 | 170.81,99.69 169.54,99.69 168.28,100.97 E17.7 | 170.81,99.69 172.09,100.97 E17.5 | 170.81,99.69 184.15,99.69 184.78,100.33 C17.1 | E14.16 183.51,51.44 184.15,52.07 184.78,52.07 C14.1 | E15.14 180.97,65.41 181.61,66.04 182.25,66.04 C15.1 | E16.14 180.97,79.38 181.61,80.01 182.25,80.01 C16.1 | 182.88,80.64 172.09,80.64 170.81,79.38 E16.10 | 182.88,80.64 C16.1 | 182.88,80.64 C16.1 | E23.16 127.64,48.9 128.27,49.53 128.91,49.53 C23.1 | E21.16 127.64,18.41 128.27,19.05 128.91,19.05 C21.1 | E22.16 127.64,33.66 128.27,34.29 128.91,34.29 C22.1 | E20.14 153.03,94.61 153.67,95.25 154.31,95.25 C20.1 | 154.94,84.45 151.76,84.45 150.5,85.72 E19.2 | 154.94,84.45 C19.1 154.94,84.45 | E24.14 125.09,64.14 125.73,64.77 126.36,64.77 C24.1 127.64,64.77 128.27,65.41 144.15,65.41 | 144.15,65.41 142.88,64.14 E18.10 | 152.4,65.41 154.94,65.41 C18.1
  Bottom 0.508: 152.4,65.41 144.15,65.41 | 152.4,65.41 152.4,64.77 E18.14 152.4,62.23 166.37,62.23 169.54,59.05 E14.6 | IC8.8 23.5,60.33 24.13,60.96 27.3,60.96 C39.1 | SL1.1 19.05,73.66 19.68,73.03 31.75,73.03 C40.+ 34.29,73.03 42.55,81.28 55.24,81.28 C37.1 56.52,81.28 57.78,82.55 73.66,82.55 74.93,81.28 75.56,81.28 R18.2 | C35.1 50.16,34.29 49.53,34.29 48.9,33.66 E35.14 47.62,32.38 40.64,25.4 31.11,25.4 R2.2 29.84,25.4 28.57,26.67 27.3,26.67 26.04,25.4 R20.2 | 20.95,13.97 19.68,13.97 18.41,12.7 R8.2 | 20.95,13.97 22.23,12.7 R7.2 | 20.95,13.97 28.57,13.97 29.84,12.7 R3.2 | R1.2 20.95,25.4 22.23,25.4 R9.2 | C38.1 51.44,92.71 54.61,95.89 66.67,95.89 67.94,94.61 IC7.8 69.22,94.61 72.39,94.61 73.03,95.25 C34.1 | C33.1 73.03,69.85 72.39,69.22 69.22,69.22 IC9.8 | C26.1 126.36,95.25 125.73,95.25 125.09,94.61 E26.14 123.83,94.61 122.56,95.89 112.39,95.89 | E32.14 99.69,94.61 100.33,95.25 100.97,95.25 C32.1 101.6,95.89 112.39,95.89 | 112.39,95.89 113.67,94.61 E26.10 | IC3.8 87,18.41 88.27,19.68 97.16,19.68 98.42,18.41 IC4.8 99.69,18.41 100.33,18.41 100.97,19.05 C27.1 | 99.06,34.92 101.6,34.92 C28.1 | 99.06,34.92 88.27,34.92 87,33.66 IC2.8 | 99.06,34.92 99.06,34.29 IC1.8 | 127,80.64 124.46,80.64 | 124.46,80.64 121.92,80.64 | 121.92,80.64 118.75,80.64 117.47,79.38 E25.11 116.2,79.38 114.94,80.64 101.6,80.64 C31.1 | 127,80.64 C25.1 127,80.64 | 121.92,80.64 121.92,80.01 E25.13 | 124.46,80.64 124.46,80.01 E25.14 | 140.34,80.64 141.6,79.38 E19.10 | 140.34,80.64 127,80.64 | IC5.8 99.69,48.9 100.33,49.53 100.97,49.53 C29.1 | C30.1 100.97,63.5 99.69,63.5 E30.14 98.42,62.87 97.16,61.59 95.89,61.59 94.61,62.87 E30.12
  Bottom 0.508: R6.2 71.75,60.96 87.63,60.96 88.9,62.23 E30.10 | 140.34,80.64 150.5,80.64 151.76,79.38 E19.14 | 154.94,84.45 170.81,84.45 172.09,85.72 E16.4
WRT  (via drill 0.61)
  Top 0.254: 170.18,76.2 171.45,77.47 171.45,80.01 173.99,82.55 173.99,90.17 176.53,92.71 176.53,95.25 181.61,100.33 181.61,102.87 182.25,103.5 191.77,103.5 191.77,100.33 192.41,99.69 197.49,99.69 197.49,100.97 E10.5 | 170.18,76.2 168.91,74.93 168.91,67.31 170.18,66.04 E15.10 | v73.66,83.82 64.14,93.34 IC7.6 | 170.18,76.2 168.91,77.47 v168.91,80.64
  Bottom 0.254: v73.66,83.82 74.93,82.55 111.76,82.55 | 111.76,82.55 113.03,83.82 113.03,88.27 114.94,88.27 115.57,87.63 115.57,84.45 120.02,84.45 121.28,85.72 E25.2 | v168.91,80.64 166.37,83.19 114.94,83.19 114.3,82.55 111.76,82.55
XDR2
  Top 0.254: E10.2 206.38,102.23 207.65,103.5 214,103.5 214,69.22 218.44,64.77 E5.8
  Bottom 0.254: E5.8 219.07,62.87 220.34,61.59 226.69,61.59 227.97,62.87 E5.12
XDR2\  (via drill 0.61)
  Top 0.254: v188.59,21.59 191.13,24.13 v191.13,59.69 | v220.98,59.05 220.98,62.23 E5.9 | v44.45,60.33 44.45,35.56 43.18,34.29 E35.12 | v111.76,75.56 111.76,77.47 E25.9 | v114.3,75.56 116.84,73.03 116.84,72.39 E24.4 | v165.1,15.24 159.38,9.53 159.38,2.54 158.12,1.27 132.08,1.27 v132.08,72.39
  Bottom 0.254: v188.59,21.59 179.07,21.59 175.9,18.41 E12.13 174.62,17.14 172.72,15.24 v165.1,15.24 | v191.13,59.69 220.34,59.69 v220.98,59.05 | E5.10 222.88,62.87 221.62,62.87 E5.9 | v44.45,60.33 48.9,64.77 73.03,64.77 76.2,61.59 87,61.59 87.63,62.23 87.63,67.31 109.22,67.31 111.12,69.22 114.94,69.22 116.2,70.48 E24.4 117.47,71.75 118.75,73.03 131.44,73.03 v132.08,72.39 | v114.3,75.56 v111.76,75.56
XFER_REQ  (via drill 0.61)
  Top 0.254: v109.22,58.42 113.03,62.23 113.03,72.39 110.49,74.93 110.49,95.25 115.57,100.33 v115.57,106.05 | v143.51,107.31 146.05,104.78 146.05,96.52 147.32,95.25 E20.12 147.32,92.71 147.32,87.63 E19.3
  Bottom 0.254: v109.22,58.42 80.01,58.42 79.38,57.78 42.55,57.78 41.27,56.52 E36.4 | v115.57,106.05 116.84,107.31 v143.51,107.31

## Text on the board
Bottom: RX08 Floppy Interface | VRS
tPlace: RX08 Floppy Interface | VRS
tNames: GND | VCC